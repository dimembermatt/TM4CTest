# Keil uVision project TM4CTest.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4CAnalysis +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\TM4C123Drivers;..\..\TM4CTest
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ../TM4C123Drivers/inc/: startup.s
    ../TM4C123Drivers/lib/GPIO/: GPIO.c
    ../TM4C123Drivers/lib/PLL/: PLL.c
    ../TM4C123Drivers/lib/FaultHandler/: FaultHandler.c
    ../TM4C123Drivers/lib/Timer/: Timer.c
    ../TM4C123Drivers/lib/UART/: UART.c
    ../TM4C123Drivers/lib/SSI/: SSI.c
    ../TM4C123Drivers/lib/PWM/: PWM.c
    ../TM4C123Drivers/lib/I2C/: I2C.c
    ../TM4C123Drivers/lib/DAC/: DAC.c
    ../TM4C123Drivers/lib/ADC/: ADC.c
